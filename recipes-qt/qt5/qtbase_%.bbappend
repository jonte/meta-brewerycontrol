PACKAGECONFIG_remove_qemux86-64 = "gl"
PACKAGECONFIG_append_qemux86-64 = "eglfs"

DEPENDS_qemux86-64 = "mesa"
