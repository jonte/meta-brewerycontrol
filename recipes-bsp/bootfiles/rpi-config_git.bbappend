PACKAGES = ""

# Use fake KMS driver
VC4DTBO = "vc4-fkms-v3d"

ENABLE_I2C = "1"
