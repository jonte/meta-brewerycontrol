require python-pigpio.inc

SRC_URI[md5sum] = "17c1a662f43b17a0c7e671a0a351d468"
SRC_URI[sha256sum] = "df5e430e5c026c95f575cb50ccd18eb37d41be4e0bbbde070ab332dae27fdf58"

inherit setuptools3
