require python-simple-pid.inc

SRC_URI = "https://files.pythonhosted.org/packages/aa/c3/ddf8bb48dee7bdbfb6e2376b179a64c8c2c590308ad05b47c02941959a71/simple-pid-${PV}.tar.gz"
SRC_URI[md5sum] = "5892b40a69624d8e6064c1569c681190"
SRC_URI[sha256sum] = "d1192b4c42ea5b3d278bb85b565841acb6292e60af2fb31f28c56eb8e704326d"

inherit setuptools3
