require python-colorzero.inc

SRC_URI[md5sum] = "7581c4b7fc5f52bf41422e4bbb29731a"
SRC_URI[sha256sum] = "acba47119b5d8555680d3cda9afe6ccc5481385ccc3c00084dd973f7aa184599"

inherit setuptools3
