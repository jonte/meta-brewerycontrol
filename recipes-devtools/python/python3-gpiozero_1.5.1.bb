require python-gpiozero.inc

SRC_URI[md5sum] = "3783098afbc8e0997a70e5595a365adf"
SRC_URI[sha256sum] = "ae1a8dc4e6e793ffd8f900968f3290d218052c46347fa0c0503c65fabe422e4d"

inherit setuptools3
