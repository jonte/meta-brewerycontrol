include python-openapi-spec-validator.inc

LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=e3fc50a88d0a364313df4b21ef20c29e"

SRC_URI[md5sum] = "0b5a16d27b5ef20972d9d729c7aa2e07"
SRC_URI[sha256sum] = "e489c7a273284bc78277ac22791482e8058d323b4a265015e9fcddf6a8045bcd"

inherit setuptools3
