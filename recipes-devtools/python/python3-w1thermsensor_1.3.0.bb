require python-w1thermsensor.inc

SRC_URI[md5sum] = "23f5c2d9629c7a0ecf6bea1fa2d57bd0"
SRC_URI[sha256sum] = "a53b339c8a99f4093d5da47c2295f571cbac9e5d72a0a1535f60f847b8c65df9"

inherit setuptools3
